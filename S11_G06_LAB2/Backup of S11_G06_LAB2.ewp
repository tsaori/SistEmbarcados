# IAR project Backup of S11_G06_LAB2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: ..\..\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: S11_G06_LAB2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: driverlib.a S11_G06_LAB2.c startup_TM4C1294.s system_TM4C1294_TW.c uartstdio.c
